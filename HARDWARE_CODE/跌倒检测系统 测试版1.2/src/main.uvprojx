# Keil uVision project main.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: main +hex
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: ..\system\delay;..\system\sys;..\system\usart;..\hardware
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group system
    ../system/delay/: delay.c
    ../system/sys/: sys.c
    ../system/usart/: usart.c
  group scr
    ./: main.c
  group hardware
    ../hardware/: key.c led.c usart2.c gsm.c gps.c mpu6050.c STMIIC.c usart3.c falldown.c buzzer.c io.c
    ../system/usart/: usart.c
